# Keil uVision project lj2330612021.uvprojx, settings and files
target lj2330612021 (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: lj2330612021 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../RT-Thread;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/components/finsh/inc/;../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/include/;../BUZZER;../DHT11;../ESP8266;../Key;../Led;../Light_Sensor;../MQ2;../OLED;../PIR_Sensor;../Relay;../Utils
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/RT-Thread/RTOS/shell
    ../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/components/finsh/src/: cmd.c msh.c msh_file.c msh_parse.c shell.c
  group Middlewares/RT-Thread/RTOS/libcpu
    ../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group Middlewares/RT-Thread/RTOS/kernel
    ../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/bsp/_template/cubemx_config/: board.c
    ../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group BUZZER
    ../BUZZER/: buzzer.c
  group DHT11
    ../DHT11/: dht11.c
  group ESP8266
    ../ESP8266/: esp8266_init.c mqtt_worker.c onenet_cmd.c onenet_kv.c platform_mqtt_esp8266_impl.c platform_uart_stm32_impl.c platform_wifi_esp8266_impl.c
  group Key
    ../Key/: key.c
  group Led
    ../Led/: led.c
  group Light_Sensor
    ../Light_Sensor/: light_sensor.c
  group MQ2
    ../MQ2/: mq2.c
  group OLED
    ../OLED/: oled.c
  group PIR_Sensor
    ../PIR_Sensor/: pir_sensor.c
  group Relay
    ../Relay/: relay.c
  group Utils
    ../Utils/: cJSON.c md5.c
software components: CMSIS:CORE 6.1.0
